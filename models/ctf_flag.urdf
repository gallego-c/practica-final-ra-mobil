Commit message: millor bandera

File: models/ctf_flag.urdf (robot description, URDF)
Before this commit: robot ctf_flag, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.70 radius=0.03; visual cylinder length=0.02 radius=0.22
